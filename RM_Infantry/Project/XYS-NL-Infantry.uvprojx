# Keil uVision project XYS-NL-Infantry.uvprojx, settings and files
target XYS-NL-Infantry (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: infantry +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427X,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CMSIS;..\FWLIB\inc;..\user\mpu6050;..\User\DSP\Include;..\User\FreeRTOS\include;..\User\FreeRTOS\portable;..\User\FreeRTOS\portable\RVDS\ARM_CM4F;..\user\user_lib;..\User\hardware\ADC;..\User\hardware\BUZZER;..\User\hardware\delay;..\User\hardware\EXIT_Init;..\User\hardware\CAN;..\User\hardware\LED;..\User\hardware\FLASH;..\User\hardware\FRIC;..\User\hardware\LASER;..\User\hardware\POWER_CTRL;..\User\hardware\RC;..\User\hardware\RNG;..\User\hardware\SPI;..\User\hardware\SYS;..\user\hardware\timer;..\User\APP\Calibrate_Task;..\User\APP\CAN_Receive;..\User\APP\Detect_Task;..\User\APP\FreeRTOS_Middleware;..\User\APP\Gimbal_Task;..\User\APP\INS_Task;..\User\APP\pid;..\User\APP\Remote_Control;..\User\APP\Shoot;..\User\APP\Start_Task;..\User\APP\User_Task;..\user\hardware\usart6;..\user\mpu6050\eMPL;..\user\AHRS;..\user\APP\chassis_task;..\user\APP\shoot_task;..\user\hardware\usart7;..\user;..\user\hardware\magazine;..\user\hardware\motor_driver;..\user\APP\gimbal_key_control;..\user\hardware\surper_cap;..\user\hardware\uart7
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../startup/: startup_stm32f427xx.s
  group CMSIS
    ../CMSIS/: stm32f4xx_it.c system_stm32f4xx.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group freeRTOS
    ../user/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../user/FreeRTOS/portable/MemMang/: heap_4.c
    ../user/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group DSP
    ../user/DSP/: arm_cortexM4lf_math.lib
  group user_lib
    ../user/user_lib/: user_lib.c
  group main
    ../user/: main.c kalman.c kalman_filter.c crc.c judge.c vision.c
  group hardware
    ../user/hardware/adc/: adc.c
    ../user/hardware/buzzer/: buzzer.c
    ../user/hardware/can/: can.c
    ../user/hardware/delay/: delay.c
    ../user/hardware/exit_init/: exit_init.c
    ../user/hardware/flash/: flash.c
    ../user/hardware/fric/: fric.c
    ../user/hardware/laser/: laser.c
    ../user/hardware/led/: led.c
    ../user/hardware/power_ctrl/: power_ctrl.c
    ../user/hardware/rc/: rc.c
    ../user/hardware/rng/: rng.c
    ../user/hardware/spi/: spi.c
    ../user/hardware/sys/: sys.c
    ../user/hardware/timer/: timer.c
    ../user/hardware/usart6/: usart6.c
    ../user/hardware/magazine/: magazine.c
    ../user/hardware/motor_driver/: motor_driver.c
    ../user/hardware/surper_cap/: super_cap.c
    ../user/hardware/uart7/: uart7.c
  group APP
    ../user/APP/CAN_receive/: CAN_receive.c
    ../user/APP/chassis_task/: chassis_task.c chassis_behaviour.c
    ../user/APP/FreeRTOS_middleware/: FreeRTOS_middleware.c
    ../user/APP/gimbal_task/: gimbal_task.c
    ../user/APP/pid/: pid.c
    ../user/APP/remote_control/: remote_control.c
    ../user/APP/start_task/: start_task.c
    ../user/APP/shoot_task/: shoot_task.c
    ../user/APP/gimbal_key_control/: gimbal_key_control.c
  group MPU6050
    ../user/mpu6050/: mpu6050.c myiic.c
    ../user/mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
